# Keil uVision project WatchX-II.uvprojx, settings and files
target WatchX-II (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ACGU7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WatchX-II
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: LIBRARY_VERSION,ARDUINO=111
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\WatchX;..\Libraries\SdFat\src;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\Source\include;..\Libraries\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Basic
    ../WatchX/Basic/: main.cpp Initialization.cpp rt_sys.cpp system.c FileGroup.h SysConfig.h TasksManage.h TasksManage.cpp
  group BSP
    ../WatchX/BSP/: BSP.h BSP_Backlight.cpp BSP_SD_NAND.cpp BSP_Button.cpp BSP_Power.cpp BSP_MotorLRA.cpp BSP_IMU.cpp BSP_ParticleSensor.cpp BSP_TouchPad.cpp BSP_ComMaster.cpp
  group BSP/Built-in
    ../WatchX/BSP/Built-in/: BSP_I2C_Scan.cpp BSP_IMU.cpp BSP_ParticleSensor.cpp BSP_TouchPad.cpp
  group GUI
    ../WatchX/GUI/: DisplayPrivate.h DisplayBasic.cpp DisplayPage.cpp DisplayStatusBar.cpp DisplayAppWin.cpp DisplayError.cpp lv_port_disp.cpp lv_port_indev.cpp lv_port_log.cpp
  group GUI/Page
    ../WatchX/GUI/Page/: Page_EXAMPLE.cpp Page_DialPlate.cpp Page_MainMenu.cpp Page_Calculator.cpp Page_Stopwatch.cpp Page_HeartRate.cpp Page_Settings.cpp Page_TimeSet.cpp Page_BacklightSet.cpp
  group GUI/lv_ext
    ../WatchX/GUI/lv_ext/: lv_label_anim_effect.cpp lv_theme_watchx.c lv_obj_ext_func.cpp lv_anim_timeline.cpp
  group GUI/IMG
    ../WatchX/GUI/IMG/: IMG_DialPlate.c IMG_CHNSecond.c IMG_Heart.c IMG_Power.c IMG_Bluetooth.c IMG_Calculator.c IMG_FileExplorer.c IMG_Game.c IMG_HeartRate.c IMG_Music.c IMG_Settings.c IMG_Sleep.c IMG_Sport.c IMG_Stopwatch.c IMG_AppShadow.c IMG_StopwatchAdd.c IMG_StopwatchPause.c IMG_StopwatchReset.c IMG_StopwatchStart.c IMG_CalcBG.c IMG_HeartrateTinyheart.c
  group GUI/Font
    ../WatchX/GUI/Font/: Font_RexBold_28.c Font_RexBold_89.c Font_MicrosoftYaHei_28.c Font_MicrosoftYaHei_50.c Font_MicrosoftYaHei_16.c
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/PageManager/: PageManager.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/FT6336U/: FT6336U.cpp
    ../Libraries/LIS2DS12/: LIS2DS12_ACC.cpp
    ../Libraries/MAX3010x/src/: heartRate.cpp MAX30105.cpp spo2_algorithm.cpp
  group lvgl
    ../Libraries/: lv_conf.h
    ../Libraries/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Libraries/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lv_examples
    ../Libraries/: lv_ex_conf.h
    ../Libraries/lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
    ../Libraries/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
    ../Libraries/lv_examples/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../Libraries/lv_examples/src/lv_demo_stress/: lv_demo_stress.c
  group FreeRTOS
    ../Libraries/FreeRTOS/: FreeRTOSConfig.h cpu_utils.c
    ../Libraries/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Libraries/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Libraries/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SdFat
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c HardwareSerial.cpp Print.cpp Stream.cpp SPI.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: adc.c delay.c exti.c gpio.c timer.c pwm.c i2c.c rtc.c
  group cm_backtrace
    ../Libraries/cm_backtrace/: cmb_cfg.h cm_backtrace.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:BKPR 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:FMC 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:I2C 1.0.1, Device:StdPeriph Drivers:PWR 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:RTC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
